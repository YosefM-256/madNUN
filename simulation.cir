** full circuit **
*
* NI Multisim to SPICE Netlist Export
* Generated by: mizra
* Mon, Sep 05, 2022 20:29:00
*

*## Multisim Component V8 ##*
vV8 SC1_l_Vin_dig 0 dc 5 ac 0 0

*## Multisim Component V4 ##*
vV4 SC2_l_Vin_dig 0 dc 0 ac 0 0

*## Multisim Component V2 ##*
vV2 SC3_l_Vin_dig 0 dc 0 ac 0 0

*## Multisim Component V3 ##*
vV3 1 0 dc 0 ac 0 0

*## Multisim Component V7 ##*
vV7 15 0 dc 5 ac 0 0

*## Multisim Component V1 ##*
vV1 2 0 dc 1.806641 ac 0 0

*## Multisim Component RB1 ##*
rRB1 Vb_1k Vb 1000
.model vresRB1 r(  )

*## Multisim Component RB2 ##*
rRB2 Vb_100 Vb 100
.model vresRB2 r(  )

*## Multisim Component Q10 ##*
mQ10 2 15 Vb_1k Vb_1k TN2501

*## Multisim Component Q9 ##*
mQ9 2 1 Vb_100 Vb_100 TN2501

*## Multisim Component V15 ##*
vV15 -1V 0 dc -1 ac 0 0

*## Multisim Component V14 ##*
vV14 12V 0 dc 12 ac 0 0

*## Multisim Component Q1 ##*
qQ1 SC7_l_V_in Vb 0 Q2N2222A__BJT_NPN__1

*## Multisim Component V6 ##*
vV6 6 0 dc 4.943848 ac 0 0

*## Multisim Component V5 ##*
vV5 4 0 dc 12 ac 0 0

*## Multisim Component RC5 ##*
rRC5 7 0 100000
.model vresRC5 r(  )

*## Multisim Component RC4 ##*
rRC4 SC1_l_Vin_AN 7 100000
.model vresRC4 r(  )

*## Multisim Component U2 ##*
xU2 5 7 6 0 4 741__OPAMP__1

*## Multisim Component Q2 ##*
qQ2 4 5 SC1_l_Vin_AN QBD135__BJT_NPN__1

*## Multisim Component RC3 ##*
rRC3 V_an_10 SC7_l_V_in 10
.model vresRC3 r(  )

*## Multisim Component RC2 ##*
rRC2 V_an_100 SC7_l_V_in 100
.model vresRC2 r(  )

*## Multisim Component RC1 ##*
rRC1 V_an_1k SC7_l_V_in 1000
.model vresRC1 r(  )

.SUBCKT 741__OPAMP__1 1 2 3 4 5
* EWB Version 4 - 5 Terminal Opamp Model
* nodes: 3=+ 2=- 1=out 5=V+ 4=V-
* VCC= 15 VEE= -15 CC= 3e-011 A= 200000 RI= 2e+006
* RO= 75 VOS= 0.001 IOS= 2e-008 IBS= 8e-008
* VSW+= 14 VSW-= -14 CMMR= 90
* ISC= 0.025 SR= 0.5 Fu= 1e+006 Pm= 6.09112e-007
    VC 5 15 DC 1.68573V
    VE 12 4 DC 1.68573V
    IEE 10 4 DC 1.516e-005A
    R1  10  0 10Gohm
    R6  11  0 100Kohm
    R7   5  4 1Kohm
    Rc1  6  5 5305.16ohm
    Rc2  5  7 5305.16ohm
    Re1  9 10 1839.19ohm
    Re2  8 10 1839.19ohm
    Ro1  1 14 37.5ohm
    Ro2 14  0 37.5ohm
    Ree 10  0 1.31926e+007ohm
    Rcc  0 13 2.20906e-005ohm
    Cee  0 10 1e-012
    Cc  14 11 3e-011
    C1   6  7 1e-016
    GA  11  0  6  7 0.000188496
    GC   0 13  1  0 45268.1
    GB  14  0 11  0 282.942
    GCM  0 11 10  0 5.96075e-009
    D1  14 13 Dopamp1
    D2  13 14 Dopamp1
    D3   1 15 Dopamp2
    D4  12  1 Dopamp2
    Qt1  6 2 9 Qopamp1
    Qt2  7 3 8 Qopamp2
.MODEL Dopamp1 D (Is=7.53769e-014A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Dopamp2 D (Is=8e-016A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Qopamp1 NPN (Is=8e-016A BF=83.3333 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.MODEL Qopamp2 NPN (Is=8.30948e-016A BF=107.143 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.ENDS

.MODEL Q2N2222A__BJT_NPN__1 NPN IS =3.0611E-14 NF =1.00124 BF =220 IKF=0.52
+              VAF=104 ISE=7.5E-15 NE =1.41 NR =1.005 BR =4 IKR=0.24
+              VAR=28 ISC=1.06525E-11 NC =1.3728 RB =0.13 RE =0.22
+              RC =0.12 CJC=9.12E-12 MJC=0.3508 VJC=0.4089
+              CJE=27.01E-12 TF =0.325E-9 TR =100E-9

.MODEL TN2501 NMOS(LEVEL=3 RS=0.07 NSUB=1.0E15 KAPPA=0.20 TPG=1 CGDO=3.1716E-10 RD=1.2
+	VTO=0.700 VMAX=1.0E7 ETA=0.0223089 NFS=6.6E10 TOX=725E-10 LD=1.698E-9
+	UO=862.425 XJ=6.4666E-7 THETA=1.0E-5 CGSO=2.50E-9 L=2.0E-6 W=59E-3)

.MODEL QBD135__BJT_NPN__1 NPN(
+ IS = 4.815E-14
+ NF = 0.9897
+ ISE = 1.389E-14
+ NE = 1.6
+ BF = 124.2
+ IKF = 1.6
+ VAF = 222
+ NR = 0.9895
+ ISC = 1.295E-13
+ NC = 1.183
+ BR = 13.26
+ IKR = 0.29
+ VAR = 81.4
+ RB = 0.5
+ IRB = 1E-06
+ RBM = 0.5
+ RE = 0.165
+ RC = 0.096
+ XTB = 0
+ EG = 1.11
+ XTI = 3
+ CJE = 1.243E-10
+ VJE = 0.7313
+ MJE = 0.3476
+ TF = 6.478E-10
+ XTF = 29
+ VTF = 2.648
+ ITF = 3.35
+ PTF = 0
+ CJC = 3.04E-11
+ VJC = 0.5642
+ MJC = 0.4371
+ TR = 1E-32
+ CJS = 0
+ VJS = 0.75
+ MJS = 0.333
+ FC = 0.9359 )

** C_switch **

*## Multisim Component RC6 ##*
rRC6 SC1_l_Vin_AN 24 100000
.model vresRC6 r(  )

*## Multisim Component Q8 ##*
xQ8 24 SC1_l_Vin_dig 0 ZVN0124__MOS_ENH_N__1

*## Multisim Component Q7 ##*
xQ7 V_an_10 24 SC1_l_Vin_AN NTA4151P/ON__MOS_ENH_P__1

.SUBCKT ZVN0124__MOS_ENH_N__1 3 4 5
*               D G S
M1 3 2 5 5 MN0124
RG 4 2 225
RL 3 5 2.4E7
D1 5 3 DN0124
.MODEL MN0124 NMOS VTO=1.5512 RS=1.436 RD=9.254 IS=1E-15 KP=1.077
+CGSO=60E-12 CGDO=2E-12 CBD=36E-12 PB=1 LAMBDA=0
.MODEL DN0124 D IS=3.071E-12 N=1.026 RS=0.511
.ENDS ZVN0124

.SUBCKT NTA4151P/ON__MOS_ENH_P__1  1 2 3
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Oct  4, 10
* MODEL FORMAT: PSpice
* Symmetry POWER MOS Model (Version 1.0)
* External Node Designations
* Node 1 -> Drain
* Node 2 -> Gate
* Node 3 -> Source
M1 9 7 8 8 MM L=100u W=100u
* Default values used in MM:
* The voltage-dependent capacitances are
* not included. Other default values are:
*   RS=0 RD=0 LD=0 CBD=0 CBS=0 CGBO=0
.MODEL MM PMOS LEVEL=1 IS=1e-32
+VTO=-0.868304 LAMBDA=0.0695331 KP=4.15322
+CGSO=1.37892e-06 CGDO=1.15666e-07
RS 8 3 0.165069
D1 1 3 MD
.MODEL MD D IS=9.46735e-09 RS=0.233288 N=1.5 BV=27.9
+IBV=0.00025 EG=1 XTI=1 TT=2.5e-09
+CJO=2.21746e-11 VJ=2.55501 M=0.749801 FC=0.5
RDS 3 1 1.33e+11
RD 9 1 0.0301336
RG 2 7 26.3891
D2 5 4 MD1
* Default values used in MD1:
*   RS=0 EG=1.11 XTI=3.0 TT=0
*   BV=infinite IBV=1mA
.MODEL MD1 D IS=1e-32 N=50
+CJO=6.92221e-11 VJ=0.5 M=0.9 FC=1e-08
D3 5 0 MD2
* Default values used in MD2:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   BV=infinite IBV=1mA
.MODEL MD2 D IS=1e-10 N=0.4 RS=3.00001e-06
RL 5 10 1
FI2 7 9 VFI2 -1
VFI2 4 0 0
EV16 10 0 9 7 1
CAP 11 10 3.02409e-10
FI1 7 9 VFI1 -1
VFI1 11 6 0
RCAP 6 10 1
D4 6 0 MD3
* Default values used in MD3:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   RS=0 BV=infinite IBV=1mA
.MODEL MD3 D IS=1e-10 N=0.4
.ENDS NTA4151P/ON

** C_switch **

*## Multisim Component RC7 ##*
rRC7 SC1_l_Vin_AN 30 100000
.model vresRC7 r(  )

*## Multisim Component Q4 ##*
xQ4 30 SC2_l_Vin_dig 0 ZVN0124__MOS_ENH_N__1

*## Multisim Component Q3 ##*
xQ3 V_an_100 30 SC1_l_Vin_AN NTA4151P/ON__MOS_ENH_P__1

** C_switch **

*## Multisim Component RC8 ##*
rRC8 SC1_l_Vin_AN 36 100000
.model vresRC8 r(  )

*## Multisim Component Q6 ##*
xQ6 36 SC3_l_Vin_dig 0 ZVN0124__MOS_ENH_N__1

*## Multisim Component Q5 ##*
xQ5 V_an_1k 36 SC1_l_Vin_AN NTA4151P/ON__MOS_ENH_P__1

** V_div **

*## Multisim Component U1 ##*
xU1 V_an_10 43 12V -1V 43 OPA234/TI__OPAMP__1

*## Multisim Component Rm8 ##*
rRm8 SC4_l_V_out 0 10000
.model vresRm8 r(  )

*## Multisim Component Rm7 ##*
rRm7 SC4_l_V_out 43 40000
.model vresRm7 r(  )

* OPA234
*****************************************************************************
* (C) Copyright 2011 Texas Instruments Incorporated. All rights reserved.
*****************************************************************************
** This model is designed as an aid for customers of Texas Instruments.
** TI and its licensors and suppliers make no warranties, either expressed
** or implied, with respect to this model, including the warranties of
** merchantability or fitness for a particular purpose.  The model is
** provided solely on an "as is" basis.  The entire risk as to its quality
** and performance is with the customer.
*****************************************************************************
*
* This model is subject to change without notice. Texas Instruments
* Incorporated is not responsible for updating this model.
*
*****************************************************************************
*
** Released by: Analog eLab Design Center, Texas Instruments Inc.
* Part: OPA234
* Date: 01JUL2011
* Model Type: ALL IN ONE
* Simulator: PSPICE
* Simulator Version: 16.0.0.p001
* EVM Order Number: N/A
* EVM Users Guide: N/A
* Datasheet: SBOS055B   MAY 1996   REVISED APRIL 2008
*
* Model Version: 1.0
*
*****************************************************************************
*
* Updates:
*
* Version 1.0 :
* Release to Web
*
*****************************************************************************
* This model is applicable to OPA234, OPA2234, OPA4234
* connections:   non-inverting input
*                | inverting input
*                | | positive power supply
*                | | | negative power supply
*                | | | | output
*                | | | | |
*****************************************************************************
.SUBCKT OPA234/TI__OPAMP__1   1 2 3 4 5
*
C1   11 12 6.995E-12
C2    6  7 30E-12
DC    5 53 DX
DE   54  5 DX
DLP  90 91 DX
DLN  92 90 DX
DP    4  3 DX
EGND 99  0 POLY(2) (3,0) (4,0) 0 .5 .5
FB    7 99 POLY(5) VB VC VE VLP VLN 0 479.3E6 -480E6 480E6 480E6 -480E6
GA    6  0 11 12 65.97E-6
GCM   0  6 10 99 1.046E-9
IEE   3 10 DC 6.100E-6
HLIM 90  0 VLIM 1E3
Q1   11  2 13 QX
Q2   12  64 14 QX
R2    6  9 100.0E3
RC1   4 11 15.16E3
RC2   4 12 15.16E3
RE1  13 10 6.429E3
RE2  14 10 6.429E3
REE  10 99 50.00E6
RO1   8  5 10
RO2   7 99 10
VB    9  0 DC 0
VC    3 53 DC 1.3
VE   54  4 DC 0.65
VLIM  7  8 DC 0
VLP  91 0 DC 10
VLN   0 92 DC 10
* Output Supply Mirror
DQ1   20    21    DX
DQ2   22    20    DX
VQ1   21     0    0
VQ2   22     0    0
*adds quiescent plus positive output current
FQ1    3     0    POLY(1) VQ1   235E-6   1
*adds quiescent plus negative output current
FQ2    0     4    POLY(1) VQ2   235E-6  -1
*mirrors output current-used by FQ1 and FQ2
FQ3    0    20    POLY(1) VLIM 0   1
* delta Quiescent Current / delta Supplies
*determines change in IQ with change in power supply voltages
RQ     3     4    1E6
* Diff Input Capacitance
CDIF   1     2    5E-12
* Common Mode Input Capacitance
C1CM   1    99    6E-12
C2CM   2    99    6E-12
* Input Voltage Noise
VN1   61     0  0.6
VN2    0    62  0.6
DN1   61    63  DY
DN2   63    62  DY
*adds 1/f noise to model. Adjusted to agree w/actual en
EN    64     1  63   0    0.8
RN1    0    65  60.3865
RN2   65    66  60.3865
RN3   66     0  120.773
RN4    0    67  60.3865
RN5   67    68  60.3865
RN6   68     0  120.773
**************************
.MODEL DX D(IS=800.0E-18)
*adds voltage noise
.MODEL DY D(IS=1.9E-16 RS=2000 AF=1 KF=2.258E-17)
.MODEL QX PNP(IS=800.0E-18 BF=60)
.ENDS OPA234/TI
*

** V_div **

*## Multisim Component U6 ##*
xU6 V_an_100 50 12V -1V 50 OPA234/TI__OPAMP__1

*## Multisim Component Rm4 ##*
rRm4 SC5_l_V_out 0 10000
.model vresRm4 r(  )

*## Multisim Component Rm3 ##*
rRm3 SC5_l_V_out 50 40000
.model vresRm3 r(  )

** V_div **

*## Multisim Component U7 ##*
xU7 V_an_1k 57 12V -1V 57 OPA234/TI__OPAMP__1

*## Multisim Component Rm6 ##*
rRm6 SC6_l_V_out 0 10000
.model vresRm6 r(  )

*## Multisim Component Rm5 ##*
rRm5 SC6_l_V_out 57 40000
.model vresRm5 r(  )

** V_div **

*## Multisim Component U8 ##*
xU8 SC7_l_V_in 64 12V -1V 64 OPA234/TI__OPAMP__1

*## Multisim Component Rm2 ##*
rRm2 SC7_l_V_out 0 10000
.model vresRm2 r(  )

*## Multisim Component Rm1 ##*
rRm1 SC7_l_V_out 64 40000
.model vresRm1 r(  )

** Vb_div **

*## Multisim Component U3 ##*
xU3 Vb_100 18 12V -1V 18 OPA234/TI__OPAMP__1

*## Multisim Component Rm10 ##*
rRm10 SC8_l_V_out 0 10000
.model vresRm10 r(  )

*## Multisim Component Rm9 ##*
rRm9 SC8_l_V_out 18 15000
.model vresRm9 r(  )

** Vb_div **

*## Multisim Component U4 ##*
xU4 Vb_1k 17 12V -1V 17 OPA234/TI__OPAMP__1

*## Multisim Component Rm12 ##*
rRm12 SC9_l_V_out 0 10000
.model vresRm12 r(  )

*## Multisim Component Rm11 ##*
rRm11 SC9_l_V_out 17 15000
.model vresRm11 r(  )

** Vb_div **

*## Multisim Component U5 ##*
xU5 Vb 16 12V -1V 16 OPA234/TI__OPAMP__1

*## Multisim Component Rm14 ##*
rRm14 SC10_l_V_out 0 10000
.model vresRm14 r(  )

*## Multisim Component Rm13 ##*
rRm13 SC10_l_V_out 16 15000
.model vresRm13 r(  )

.dc vv1 1.782227 1.831055 0.001221
.SAVE V(sc3_l_vin_dig) V(sc2_l_vin_dig) V(sc1_l_vin_dig) V(5) V(2) V(6) V(SC1_l_Vin_AN) Ie(Qq2) V(V_an_1k) V(V_an_100) V(V_an_10) I(Rrc1) I(Rrc2) I(Rrc3) V(SC7_l_V_in) Ic(Qq1) Ib(Qq1) Ie(Qq1) V(Vb) V(1) V(15) V(Vb_100) V(Vb_1k) I(Rrb2) I(Rrb1) V(SC6_l_V_out) V(SC5_l_V_out) V(SC4_l_V_out) V(SC7_l_V_out) V(SC8_l_V_out) V(SC9_l_V_out) V(SC10_l_V_out)
.end
