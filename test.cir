** Design1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: mizra
* Fri, Sep 23, 2022 18:42:54
*

*## Multisim Component V1 ##*
vV1 2 0 dc 12 ac 0 0

*## Multisim Component RB1 ##*
rRB1 Vb_1k 0 1000
.model vresRB1 r(  )

*## Multisim Component V7 ##*
vV7 15 0 dc 5 ac 0 0

*## Multisim Component U9 ##*
mU9 2 15 Vb_1k Vb_1k TN2501__DEF__1

.MODEL TN2501__DEF__1 NMOS (LEVEL=3 RS=0.07 NSUB=1.0E15 KAPPA=0.20 TPG=1 CGDO=3.1716E-10 RD=1.2 VTO=0.700 VMAX=1.0E7 ETA=0.0223089 NFS=6.6E10 TOX=725E-10 LD=1.698E-9 UO=862.425 XJ=6.4666E-7 THETA=1.0E-5 CGSO=2.50E-9 L=2.0E-6 W=59E-3)

.op
